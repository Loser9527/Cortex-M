# Keil uVision project Future_Watch_V2.0.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Future_Watch_V2.0 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,ARM_MATH_CM4
  c include: ..\APP\dispaly;..\FWLIB\inc;..\HARDWARE\BATERY;..\HARDWARE\DMA;..\HARDWARE\GPIOX;..\HARDWARE\Heart;..\HARDWARE\IWDG;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\mlx90615;..\HARDWARE\MOTOR;..\HARDWARE\MPU6050;..\HARDWARE\RTC;..\HARDWARE\STMFLASH;..\HARDWARE\TFT_LCD;..\HARDWARE\TIME\TIME2;..\HARDWARE\TIME\TIME4;..\HARDWARE\USART_2;..\HARDWARE\USR_WIFI;..\STemwin\inc;..\STemwin\UI;..\STemwin\Lib;..\STemwin\Config;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\UCOSII\UCOSII_CONFIG;..\UCOSII\UCOSII_CORE;..\UCOSII\UCOSII_CORE;..\UCOSII\UCOSII_PORT;..\UCOSII\UCOSII_TASK;..\USER;..\HARDWARE\INTTERUPT;..\HARDWARE\INTTERUPT;..\HARDWARE\Heart;..\eMPL;..\eMPL;..\eMPL;..\APP\getdata;..\APP\getdata
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f40_41xxx.s
  group USER
    ./: main.h main.c
  group UCOSII_TASK
    ../UCOSII/UCOSII_TASK/: ucosii_task.h
  group HARDWARE
    ../HARDWARE/BATERY/: battery.c
    ../HARDWARE/DMA/: DMA.c
    ../HARDWARE/GPIOX/: gpio.c
    ../HARDWARE/Heart/: heart.c
    ../HARDWARE/IWDG/: wdg.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/mlx90615/: mlx90615.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/MPU6050/: mpu_iic.c mpu6050.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/TFT_LCD/: backlit.c FT6236.c FT6236_iic.c st7789.c
    ../HARDWARE/TIME/TIME4/: timer_4.c
    ../HARDWARE/USART_2/: usart_2.c
    ../HARDWARE/USR_WIFI/: usr_wifi.c
  group APP
    ../APP/dispaly/: display.c
    ../APP/getdata/: get_data.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../HARDWARE/INTTERUPT/: Interrupt.c
  group UCOSII_CONFIG
    ../UCOSII/UCOSII_CONFIG/: includes.h os_cfg.h
  group UCOSII_PORT
    ../UCOSII/UCOSII_CORE/: os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_core.c
  group UCOSII_CORE
    ../UCOSII/UCOSII_PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group STemWin_Config
    ../STemwin/Config/: GUI_X_Touch_Analog.c GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c GUIConf.h
    ../STemwin/OS/: GUI_X_OS.c
  group STemWin_Lib
    ../STemwin/Lib/: STemWin528_CM4_OS_Keil.lib
  group DSP_Lib
    ../FWLIB/inc/: arm_math.h
    ../FWLIB/src/: arm_cortexM4lf_math.lib
  group UI
    ../STemwin/UI/: dispwifi.c watch.c dispdata.c wifibottun.c help.c medicine.c startmcu.c connection.c
    ../STemwin/FONT/: myfont.c
  group EMPL
    ../eMPL/: inv_mpu_dmp_motion_driver.c inv_mpu.c
