# Keil uVision project Example.uvprojx, settings and files
target Example (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Example +hex
  c flags: Optim=1
  c define: STM32F030
  c include: ..\..\Libraries\CMSIS\CoreSupport;..\..\Libraries\CMSIS\DeviceSupport;..\..\Libraries\CMSIS\DeviceSupport\startup;..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\Libraries\STM32F0xx_StdPeriph_Driver\src;..\..\User;..\..\User\timer;..\..\User\usart;..\..\User\st7789;..\..\User\ft6236;..\..\User\key
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup Code
    ../../Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f030.s
  group STM32F0xx_StdPeriph_Driver
    ../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group CMSIS
    ../../Libraries/CMSIS/DeviceSupport/: system_stm32f0xx.c
  group USER
    ../../User/: main.c stm32f0xx_it.c
    ../../User/usart/: usart.c
    ../../User/timer/: timer.c
    ../../User/key/: key.c
    ../../User/st7789/: st7789.c
    ../../User/ft6236/: ft6236.c
  group DOC
    ../../Doc/: readme.txt
